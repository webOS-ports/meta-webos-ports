PREMIRRORS_append () {
cvs://.*/.* http://sources.webos-ports.org/openwebos-ports/
svn://.*/.* http://sources.webos-ports.org/openwebos-ports/
git://.*/.* http://sources.webos-ports.org/openwebos-ports/
hg://.*/.*  http://sources.webos-ports.org/openwebos-ports/
bzr://.*/.* http://sources.webos-ports.org/openwebos-ports/
}

MIRRORS_append () {
ftp://.*/.*     http://sources.webos-ports.org/openwebos-ports/
https?$://.*/.* http://sources.webos-ports.org/openwebos-ports/
}


PREMIRRORS_append () {
cvs://.*/.* http://sources.webos-ports.org/webos-ports/
svn://.*/.* http://sources.webos-ports.org/webos-ports/
git://.*/.* http://sources.webos-ports.org/webos-ports/
hg://.*/.*  http://sources.webos-ports.org/webos-ports/
bzr://.*/.* http://sources.webos-ports.org/webos-ports/
}

MIRRORS_append () {
ftp://.*/.*     http://sources.webos-ports.org/webos-ports/
https?$://.*/.* http://sources.webos-ports.org/webos-ports/
}


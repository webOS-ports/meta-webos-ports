# override the 0003_native-bindir patch with ours
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

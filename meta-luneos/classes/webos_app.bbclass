# Copyright (c) 2014-2018 LG Electronics, Inc.
#
# This class is intended to be inherited by every recipe whose component is an
# application for the webOS platform. The definition of an application is that
# it will render pixels on screen or the component installs an appinfo.json.

inherit webos_app_generate_security_files

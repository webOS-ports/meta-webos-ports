FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += " file://0001-Allow-adbd-to-be-ran-as-root.patch;striplevel=1 "

PACKAGECONFIG:remove:halium = "drm-gles2"

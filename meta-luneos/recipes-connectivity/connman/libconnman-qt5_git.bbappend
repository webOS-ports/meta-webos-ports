FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRCREV = "3bcd1bade72649f239954ec7cdc75a9151d2d596"
SRC_URI = "git://git.merproject.org/mer-core/libconnman-qt.git;protocol=https \
    file://0001bis-Don-t-use-MeeGo-as-prefix-in-order-to-make-this-a-co.patch \
"

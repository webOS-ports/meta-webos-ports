require luneos-emulator-appliance.inc

DESCRIPTION = "Developers LuneOS emulator appliance"

IMAGE_BASENAME = "luneos-dev"

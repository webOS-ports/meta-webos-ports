require luneos-fastboot-package.inc

IMAGE_BASENAME = "luneos-dev"

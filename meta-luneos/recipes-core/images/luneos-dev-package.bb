require luneos-package.inc

IMAGE_BASENAME = "luneos-dev"

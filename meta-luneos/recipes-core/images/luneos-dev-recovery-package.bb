require luneos-recovery-package.inc

IMAGE_BASENAME = "luneos-dev"

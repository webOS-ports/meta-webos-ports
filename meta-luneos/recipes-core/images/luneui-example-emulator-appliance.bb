require luneos-emulator-appliance.inc

DESCRIPTION = "LuneUI example emulator appliance"

IMAGE_BASENAME = "luneui-example"

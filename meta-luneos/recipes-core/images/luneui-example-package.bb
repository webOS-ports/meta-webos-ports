require luneos-package.inc

IMAGE_BASENAME = "luneui-example"

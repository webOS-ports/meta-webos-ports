# we need static libcrypt for busybox-static
DISABLE_STATIC = ""

PACKAGECONFIG:append = "python"

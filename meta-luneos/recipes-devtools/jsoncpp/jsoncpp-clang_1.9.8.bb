# Copyright (c) 2023 LG Electronics, Inc.

require recipes-devtools/jsoncpp/jsoncpp_${PV}.bb
require jsoncpp-clang.inc

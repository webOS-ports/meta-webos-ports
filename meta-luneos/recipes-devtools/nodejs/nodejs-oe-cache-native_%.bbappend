# https://lists.openembedded.org/g/openembedded-devel/message/110246
# https://lists.openembedded.org/g/openembedded-devel/message/110244
FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

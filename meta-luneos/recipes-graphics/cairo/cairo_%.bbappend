# needed in order to build gtk+ without x11 DISTRO_FEATURE
PACKAGECONFIG += "directfb"

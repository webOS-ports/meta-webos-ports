FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-tests-add-vboxvideo-to-tested-kernel-modules.patch"

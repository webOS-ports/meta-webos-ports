# needed to handle recent kernels xz modules
PACKAGECONFIG:append = " xz"

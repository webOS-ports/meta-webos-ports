# needed to handle recent kernels xz modules
PACKAGECONFIG_append = " xz"

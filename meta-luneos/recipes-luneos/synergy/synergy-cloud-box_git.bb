SUMMARY = "Box connector for Synergy DOCUMENTS and PHOTO.UPLOAD"
DESCRIPTION = "Box account type (OAuth2 + PKCE with a client secret) and its com.palm.service.boxnet service."

require cloud-synergy-connector.inc

CLOUD_CONNECTOR = "box"
CLOUD_SERVICE = "com.palm.service.boxnet"
CLOUD_TEMPLATE = "com.palm.boxnet"
CLOUD_ACCOUNT_DIR = "account/com.palm.boxnet"

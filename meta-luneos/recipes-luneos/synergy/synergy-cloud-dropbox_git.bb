SUMMARY = "Dropbox connector for Synergy DOCUMENTS and PHOTO.UPLOAD"
DESCRIPTION = "Dropbox account type (OAuth2 + PKCE, public client) and its com.palm.service.dropbox service. The reference connector."

require cloud-synergy-connector.inc

CLOUD_CONNECTOR = "dropbox"
CLOUD_SERVICE = "com.palm.service.dropbox"
CLOUD_TEMPLATE = "com.palm.dropbox"
CLOUD_ACCOUNT_DIR = "account/com.palm.dropbox"

SUMMARY = "Flickr connector for Synergy PHOTO.UPLOAD"
DESCRIPTION = "Flickr account type (OAuth 1.0a), its com.palm.service.flickr service and the com.palm.app.flickr-auth sign-in app. Photos only."

require cloud-synergy-connector.inc

CLOUD_CONNECTOR = "flickr"
CLOUD_SERVICE = "com.palm.service.flickr"
CLOUD_TEMPLATE = "com.palm.flickr"
CLOUD_ACCOUNT_DIR = "account/com.palm.flickr"
CLOUD_AUTH_APP = "com.palm.app.flickr-auth"


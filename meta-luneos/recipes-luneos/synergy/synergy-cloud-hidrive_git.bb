SUMMARY = "HiDrive connector for Synergy DOCUMENTS and PHOTO.UPLOAD"
DESCRIPTION = "STRATO HiDrive account type (OAuth2 with a client secret) and its com.palm.service.hidrive service."

require cloud-synergy-connector.inc

CLOUD_CONNECTOR = "hidrive"
CLOUD_SERVICE = "com.palm.service.hidrive"
CLOUD_TEMPLATE = "com.palm.hidrive"
CLOUD_ACCOUNT_DIR = "account"

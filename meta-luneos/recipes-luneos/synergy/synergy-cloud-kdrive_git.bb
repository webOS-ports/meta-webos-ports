SUMMARY = "kDrive connector for Synergy DOCUMENTS and PHOTO.UPLOAD"
DESCRIPTION = "Infomaniak kDrive account type (personal API token), its com.palm.service.kdrive service and the com.palm.app.kdrive-auth token entry app."

require cloud-synergy-connector.inc

CLOUD_CONNECTOR = "kdrive"
CLOUD_SERVICE = "com.palm.service.kdrive"
CLOUD_TEMPLATE = "com.palm.kdrive"
CLOUD_ACCOUNT_DIR = "account"
CLOUD_AUTH_APP = "com.palm.app.kdrive-auth"

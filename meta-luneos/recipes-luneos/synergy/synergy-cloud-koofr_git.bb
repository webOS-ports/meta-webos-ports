SUMMARY = "Koofr connector for Synergy DOCUMENTS and PHOTO.UPLOAD"
DESCRIPTION = "Koofr account type (OAuth2 + PKCE with a client secret) and its com.palm.service.koofr service."

require cloud-synergy-connector.inc

CLOUD_CONNECTOR = "koofr"
CLOUD_SERVICE = "com.palm.service.koofr"
CLOUD_TEMPLATE = "com.palm.koofr"
CLOUD_ACCOUNT_DIR = "account"

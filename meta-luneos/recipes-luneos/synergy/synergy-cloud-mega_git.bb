SUMMARY = "MEGA connector for Synergy DOCUMENTS and PHOTO.UPLOAD"
DESCRIPTION = "MEGA account type (email and password, end-to-end encrypted; names and file contents are decrypted on the device), its com.palm.service.mega service and the com.palm.app.mega-auth sign-in app."

require cloud-synergy-connector.inc

CLOUD_CONNECTOR = "mega"
CLOUD_SERVICE = "com.palm.service.mega"
CLOUD_TEMPLATE = "com.palm.mega"
CLOUD_ACCOUNT_DIR = "account"
CLOUD_AUTH_APP = "com.palm.app.mega-auth"

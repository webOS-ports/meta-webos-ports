SUMMARY = "pCloud connector for Synergy DOCUMENTS and PHOTO.UPLOAD"
DESCRIPTION = "pCloud account type (OAuth2 with a client secret; the US/EU API host is taken from the sign-in redirect) and its com.palm.service.pcloud service."

require cloud-synergy-connector.inc

CLOUD_CONNECTOR = "pcloud"
CLOUD_SERVICE = "com.palm.service.pcloud"
CLOUD_TEMPLATE = "com.palm.pcloud"
CLOUD_ACCOUNT_DIR = "account"

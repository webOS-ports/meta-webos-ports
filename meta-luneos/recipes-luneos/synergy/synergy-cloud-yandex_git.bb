SUMMARY = "Yandex Disk connector for Synergy DOCUMENTS and PHOTO.UPLOAD"
DESCRIPTION = "Yandex Disk account type (OAuth2 + PKCE with a client secret) and its com.palm.service.yandexdisk service."

require cloud-synergy-connector.inc

CLOUD_CONNECTOR = "yandex"
CLOUD_SERVICE = "com.palm.service.yandexdisk"
CLOUD_TEMPLATE = "com.palm.yandexdisk"
CLOUD_ACCOUNT_DIR = "account"

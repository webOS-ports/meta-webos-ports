# Needed for gst-droid
EXTRA_OECONF += "--enable-check"

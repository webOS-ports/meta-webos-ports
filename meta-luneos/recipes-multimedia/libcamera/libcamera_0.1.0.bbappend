PACKAGECONFIG = "gst"

LIBCAMERA_PIPELINES = "uvcvideo,simple,vimc"
EXTRA_OEMESON += "-Dipas=vimc"

# with the -halium appended to our TUNE_PKGARCH for some MACHINEs, libvpx fails to find the toolchain when populating RSS
ARM_INSTRUCTION_SET = "thumb"

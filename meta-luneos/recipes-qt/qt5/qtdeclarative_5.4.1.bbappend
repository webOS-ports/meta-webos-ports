FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-Allow-setting-the-source-rect-on-QSGSimpleTextureNod.patch \
"

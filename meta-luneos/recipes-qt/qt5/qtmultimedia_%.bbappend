# needed to have QtMultimedia plugins for GStreamer 1.0
PACKAGECONFIG += "gstreamer"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Set-a-transparent-background-for-contextual-menus.patch;patch=1"



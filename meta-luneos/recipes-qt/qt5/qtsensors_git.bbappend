EXTRA_QMAKEVARS_PRE += "\
    DEFINES+=\"QTSENSORS_CONFIG_PATH=\\\\\\\"${OE_QMAKE_PATH_QT_SETTINGS}/QtProject/Sensors.conf\\\\\\\"\"\
    "


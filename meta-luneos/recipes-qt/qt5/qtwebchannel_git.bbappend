LIC_FILES_CHKSUM = "file://LICENSE.FDL;md5=6d9f2a9af4c8b8c3c769f6cc1b6aaf7e \
                    file://LICENSE.GPLv2;md5=05832301944453ec79e40ba3c3cfceec \
                    file://LICENSE.LGPLv21;md5=58a180e1cf84c756c29f782b3a485c29 \
                    file://LICENSE.LGPLv3;md5=c4fe8c6de4eef597feec6e90ed62e962 \
"

QT_MODULE_BRANCH = "dev"
SRCREV = "368adbf8e75c00712c7a30eb6b8d7a7e175e89d7"

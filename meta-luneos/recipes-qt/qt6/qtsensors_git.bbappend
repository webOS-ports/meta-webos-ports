EXTRA_QMAKEVARS_PRE += "\
    SENSORS_CONFIG_PATH=/etc/xdg/QtProject/Sensors.conf\
"

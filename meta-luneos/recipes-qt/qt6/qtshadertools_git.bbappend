FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-glslang-fix-build-with-gcc-15.patch"

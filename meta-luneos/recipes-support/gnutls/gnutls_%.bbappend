EXTRA_OECONF += " \
    --with-default-trust-store-dir=/etc/ssl/certs  \
"

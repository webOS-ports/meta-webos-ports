# nicesrc and nicesink, which the Teams and Signal call media engines use to carry RTP over the
# ICE connection.
PACKAGECONFIG:append = " gstreamer"

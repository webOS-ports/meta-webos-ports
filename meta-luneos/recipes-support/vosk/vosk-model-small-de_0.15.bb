SUMMARY = "Vosk speech model: German, small"
require vosk-model.inc

VOSK_MODEL = "vosk-model-small-de-0.15"
VOSK_LANGUAGE = "de"
VOSK_LICENSE_LINE = "67"
VOSK_LICENSE_MD5 = "b4197dee31a6934aaf221359839c12e1"
SRC_URI[model.sha256sum] = "b7e53c90b1f0a38456f4cd62b366ecd58803cd97cd42b06438e2c131713d5e43"

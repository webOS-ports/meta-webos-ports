SUMMARY = "Vosk speech model: English (US), small"
require vosk-model.inc

VOSK_MODEL = "vosk-model-small-en-us-0.15"
VOSK_LANGUAGE = "en-US"
VOSK_LICENSE_LINE = "32"
VOSK_LICENSE_MD5 = "bb5cd71a409da2b13fa3bcb67a3573d1"
SRC_URI[model.sha256sum] = "30f26242c4eb449f948e42cb302dd7a686cb29a3423a8367f99ff41780942498"

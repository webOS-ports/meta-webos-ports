SUMMARY = "Vosk speech model: Spanish, small"
require vosk-model.inc

VOSK_MODEL = "vosk-model-small-es-0.42"
VOSK_LANGUAGE = "es"
VOSK_LICENSE_LINE = "69"
VOSK_LICENSE_MD5 = "1b64ef5b86f7203e1df42855ac20c96e"
SRC_URI[model.sha256sum] = "09b239888f633ef2f0b4e09736e3d9936acfd810bc65d53fad45261762c6511f"

SUMMARY = "Vosk speech model: French, small"
require vosk-model.inc

VOSK_MODEL = "vosk-model-small-fr-0.22"
VOSK_LANGUAGE = "fr"
VOSK_LICENSE_LINE = "58"
VOSK_LICENSE_MD5 = "b49bbab5d6832157cad0e0dbb924a5b2"
SRC_URI[model.sha256sum] = "cabf6180e177eb9b3a9a9d43a437bd5e549f3a7d09525e5d69a3fed787be12ad"

SUMMARY = "Vosk speech model: Italian, small"
require vosk-model.inc

VOSK_MODEL = "vosk-model-small-it-0.22"
VOSK_LANGUAGE = "it"
VOSK_LICENSE_LINE = "82"
VOSK_LICENSE_MD5 = "5738be531d1fac9b1088702e7d1f9499"
SRC_URI[model.sha256sum] = "9ec65e75861d1c6c2e457cccd932705340dcdf233f5b239f00733b4de0bf3267"

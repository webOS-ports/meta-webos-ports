SUMMARY = "Vosk speech model: Dutch, small"
require vosk-model.inc

VOSK_MODEL = "vosk-model-small-nl-0.22"
VOSK_LANGUAGE = "nl"
VOSK_LICENSE_LINE = "85"
VOSK_LICENSE_MD5 = "89092d5bb6e5a9c70b4e54b7f41f56c8"
SRC_URI[model.sha256sum] = "039811c3b829de64e4f123a9f684a53784005b212a346ac0b899dc7efce2ed0a"

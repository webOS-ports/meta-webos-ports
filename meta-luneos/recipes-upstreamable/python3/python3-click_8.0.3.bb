DESCRIPTION = Click is a Python package for creating beautiful command line interfaces in a composable way with as little code as necessary.
HOMEPAGE = httpspalletsprojects.compclick
LICENSE = Properietary
LIC_FILES_CHKSUM = fileLICENSE.rst;md5=1fa98232fd645608937a0fdc82e999b8

SRC_URI[sha256sum] = 410e932b050f5eed773c4cda94de75971c89cdb3155a72a0831139a79e5ecb5b

inherit pypi setuptools3

BBCLASSEXTEND = native nativesdk

require mojomail.inc

SUMMARY = "Common Email Service Library used by other email services"
S = "${UNPACKDIR}/${BB_GIT_DEFAULT_DESTSUFFIX}/common"

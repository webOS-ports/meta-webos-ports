# Copyright (c) 2018-2019 LG Electronics, Inc.

require webos-open-test-apps.inc
PR = "${INC_PR}.1"

SRCREV = "e67084ab52bc176fda04c645eeec0029630d7dcf"
PV = "1.0.0-7+git${SRCPV}"

SUMMARY = "webOS OSE test application"
AUTHOR = "Anish TD <anish.td@lge.com>"

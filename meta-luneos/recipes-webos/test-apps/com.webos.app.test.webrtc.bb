# Copyright (c) 2020 LG Electronics, Inc.

require webos-open-test-apps.inc

PR = "${INC_PR}.0"

SRCREV = "9ebc4e9f1f3fa337f90047e5d94ffe29aa347298"

SUMMARY = "WebRTC"
AUTHOR = "Pankaj Kumar Maharana <pankaj.maharana@lge.com>"


# Copyright (c) 2016-2019 LG Electronics, Inc.

require webos-open-test-apps.inc
PR = "${INC_PR}.2"

SRCREV = "e67084ab52bc176fda04c645eeec0029630d7dcf"
PV = "1.0.0-7+git${SRCPV}"

WEBOS_PREFERRED_GFX_IMAGE_FORMAT_ENABLED = "0"

SUMMARY = "YouTube Test Application"
AUTHOR = "Anish TD <anish.td@lge.com>"

inherit cmake_qt5
inherit webos_cmake

inherit qt6-cmake
inherit webos_cmake

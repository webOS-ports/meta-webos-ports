WEBOS_GIT_PARAM_BRANCH ?= "webOS-ports/master"

inherit webos_ports_repo

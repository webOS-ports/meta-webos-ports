WEBOS_GIT_PARAM_BRANCH ?= "webOS-ports/webOS-OSE"

inherit webos_ports_repo

# Needed for leveldb-native -> db8-native
BBCLASSEXTEND = "native"

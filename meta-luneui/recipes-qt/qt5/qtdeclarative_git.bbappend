FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += " \
    file://0001-qsgtexture-Remove-Filtering-enum-options-to-resolve-.patch \
"

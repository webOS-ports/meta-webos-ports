require webos-ports-emulator-appliance.inc

DESCRIPTION = "Developers webOS Ports emulator appliance"

IMAGE_BASENAME = "webos-ports-dev"

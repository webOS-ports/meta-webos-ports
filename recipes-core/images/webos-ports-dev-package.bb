require webos-ports-package.inc

IMAGE_BASENAME = "webos-ports-dev"

# Enable support for dealing with coredumps inside systemd
EXTRA_OECONF += "--enable-coredump"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://persistent-storage-rule-mmc-partname.patch"

PRINC := "${@int(PRINC) + 1}"

ALTERNATIVE_LINK_NAME[telinit] = "${base_sbindir}/telinit"

# work around for http://lists.linuxtogo.org/pipermail/openembedded-core/2012-October/030826.html
# Can be dropped as soon as newer oe-core with fix is used
QEMU_TARGETS += "mips"

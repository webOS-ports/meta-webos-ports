# Copyright (c) 2012 Hewlett-Packard Development Company, L.P.

FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

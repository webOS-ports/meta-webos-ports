# Copyright (c) 2013 LG Electronics, Inc.

FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

SRC_URI += " file://CVE-2007-4476.diff \
             file://CVE-2007-4131.diff \
"

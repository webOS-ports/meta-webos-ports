FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += " \
    file://0001-Bring-back-old-setRenderWithoutShowing-API-method.patch \
"

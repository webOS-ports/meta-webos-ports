DEPENDS_remove = "gstreamer gst-plugins-base"

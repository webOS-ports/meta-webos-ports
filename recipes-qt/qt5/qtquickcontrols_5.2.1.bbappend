FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-TextInput-forward-passwordCharacter-property-from-Te.patch \
"

# We need to keep track also with qtwayland-scanner as it's output format is changed from
# time to time
SRCREV = "3209f61310cb5244704e7cfa4f16044420c96747"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-Implement-additional-properties-for-QQuickWebView-to.patch \
"

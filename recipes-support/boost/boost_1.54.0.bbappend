FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://variants.CXX11.patch \
            file://lexical_cast.patch \
"

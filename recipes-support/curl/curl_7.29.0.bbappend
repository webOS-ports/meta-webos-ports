# Copyright (c) 2012 Hewlett-Packard Development Company, L.P.

DEPENDS_append_class-target = " c-ares"

EXTRA_OECONF_append_class-target = " --enable-ares"

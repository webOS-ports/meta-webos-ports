SUMMARY= "A library for handling evdev kernel devices"
LICENSE = "X11"
LIC_FILES_CHKSUM = "file://COPYING;md5=75aae0d38feea6fda97ca381cb9132eb"

SRC_URI = "http://www.freedesktop.org/software/libevdev/libevdev-1.0.tar.xz"
SRC_URI[md5sum] = "16dc171b8cd6631b266bb45c5f9634fe"
SRC_URI[sha256sum] = "6e6d1e307eff03f1c939c9af532228b19030fc896a9257a8abfa6e9b7dc91803"

inherit autotools

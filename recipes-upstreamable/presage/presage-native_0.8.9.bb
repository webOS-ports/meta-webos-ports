require presage.inc
require presage-${PV}.inc

inherit native

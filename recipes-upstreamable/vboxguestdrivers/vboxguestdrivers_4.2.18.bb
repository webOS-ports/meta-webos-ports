# Copyright (c) 2013 LG Electronics, Inc.

require ${BPN}.inc

SRC_URI[md5sum] = "99cdf054b5e36aa83b60bd49fb50f943"
SRC_URI[sha256sum] = "9dbddf393b029c549249f627d12040c1d257972bc09292969b8819a31ab78d74"

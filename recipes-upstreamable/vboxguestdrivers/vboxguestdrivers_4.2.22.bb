# Copyright (c) 2013 LG Electronics, Inc.

require ${BPN}.inc

SRC_URI[md5sum] = "919bd83956fb9604ab5abf7de6e904ab"
SRC_URI[sha256sum] = "4a017ec5fa0e0cfa830ae6c2b9d680c9b108e5fb96348e1397a7d0ea051f8bc1"

# Copyright (c) 2013-2014 LG Electronics, Inc.

require ${BPN}.inc

SRC_URI[md5sum] = "0e6e345a5bc4321bc5014258c6e9a5bb"
SRC_URI[sha256sum] = "9798acbc78b2645f2a02446ef6be181ede1a377792007af2a3280c962edc24cb"

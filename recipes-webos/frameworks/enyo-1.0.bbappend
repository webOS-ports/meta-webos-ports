PRINC := "${@int(PRINC) + 1}"

inherit webos-ports-submissions

SRCREV = "82188d68bd87ff2f32988a5ffc7b445a97bbeea5"

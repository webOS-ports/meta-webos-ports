FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

inherit webos-ports-submissions
SRCREV = "4518c1c345fdf9cc7c43a50255f5e0c8c6536839"

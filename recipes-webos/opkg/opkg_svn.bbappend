# Copyright (c) 2013 LG Electronics, Inc.

EXTRA_OECONF_class-target += "--with-opkglockfile=${localstatedir}/lock/opkg"

DEPENDS += "${VIRTUAL-RUNTIME_webappmanager}"

FILES_${PN} += "${webos_applicationsdir}/${WEBOS_APPLICATION_NAME}/plugins/"
